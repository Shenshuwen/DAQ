# Keil uVision project DAQ.uvprojx, settings and files
target DAQ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: DAQ +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/ARM_CM3;../FreeRTOS/Inc;../Application/Inc
  memory RVCT4: ROM 0x8004000 size 0xbc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: uart_drv.c spi_drv.c tim_drv.c main.c gpio.c dma.c iwdg.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_spi.c stm32f1xx_ll_gpio.c stm32f1xx_ll_dma.c stm32f1xx_ll_tim.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Inc
    ../FreeRTOS/Inc/: atomic.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h rtos.h semphr.h stack_macros copy.h stack_macros.h task.h timers.h
    ../FreeRTOS/ARM_CM3/: portmacro.h
  group FreeRTOS/Src
    ../FreeRTOS/Src/: list.c queue.c rtos.c tasks.c
    ../FreeRTOS/ARM_CM3/: heap_4.c port.c
  group Application/Comm
    ../Application/Src/: modbus.c ota.c
software components: CMSIS:CORE 4.3.0
